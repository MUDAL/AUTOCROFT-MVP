# Keil uVision project master_code.uvprojx, settings and files
target stm32f103c8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master_code
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Application
    ./: main.c
  group Graphics Application
    ./: display.c display.h
  group Master - Node Application
    ./: message.c message.h
  group High Layer API
    ./: bme280.c bme280.h bms.c bms.h button.c button.h eeprom24c16.c eeprom24c16.h hc12.c hc12.h potentiometer.c potentiometer.h system.c system.h lcd.c lcd.h
  group Low Layer API
    ./: adc.c adc.h afio.c afio.h clocks.c clocks.h dma.c dma.h exti.c exti.h gpio.c gpio.h i2c.c i2c.h iwdg.c iwdg.h systick.c systick.h uart.c uart.h
  group Generic
    ./: conversions.c conversions.h irrigation.h sensor.h sysTimer_struct.h FSM.c FSM.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
