# Keil uVision project keypad.uvprojx, settings and files
target STM32F1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keypad
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Application
    ./: main.c
  group High Level APIs
    ./: keypad.c keypad.h lcd.c lcd.h
  group Low Level APIs
    ./: clocks.c clocks.h gpio.c gpio.h systick.c systick.h
  group Generic
    ./: sysTimer_struct.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
