# Keil uVision project Master_Version_1_1.uvprojx, settings and files
target stm32f103c8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Master_Version_1_1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
  group HMI Application
    ./: hmi.c hmi.h
  group Display Application
    ./: display.c display.h
  group Master Node Communication
    ./: communication.c communication.h
  group High Layer API
    ./: bme280.c bme280.h ds3231.c ds3231.h eeprom24c16.c eeprom24c16.h hc12.c hc12.h keypad.c keypad.h lcd.c lcd.h system.c system.h
  group Low Layer API
    ./: clocks.c clocks.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h pwr.c pwr.h systick.c systick.h uart.c uart.h afio.c afio.h exti.c exti.h
  group Generic
    ./: conversions.c conversions.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
